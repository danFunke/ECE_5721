# Keil uVision project part1.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: part1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: adc.c adc.h main.c seven_segment_display_encode.c seven_segment_display_encode.h display.c display.h event.c event.h list.c list.h system_clock.c system_clock.h system_time.c system_time.h SysTick.c SysTick.h seven_segment_display.c seven_segment_display.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
